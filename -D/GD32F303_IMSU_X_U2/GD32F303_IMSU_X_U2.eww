<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\GD32F303_IMSU_X_U2.ewp</path>
    </project>
    <batchBuild />
</workspace>
