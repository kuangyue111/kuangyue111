# IAR project GD32F303_IMSU_X_U2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F303xC GD GD32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: GD32F30X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: CMSIS; CMSIS\GD\GD32F30x\Include; CMSIS\GD\GD32F30x\Source; CMSIS\GD\GD32F30x\Source\IAR; GD32F30x_standard_peripheral\Include; GD32F30x_standard_peripheral\Source; App\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GD32F303_IMSU_X_U2.hex
  ILINK.IlinkOutputFile: GD32F303_IMSU_X_U2.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F303xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Sources/Application
    App/: main.c
  group Sources/Application/include
    App/Include/: BSP.h Calibration.h can.h configure.h EEPROM.h gd32f30x_it.h I2C.h includes.h systick.h
  group Sources/Application/source
    App/Source/: BSP.c Calibration.c can.c EEPROM.c gd32f30x_it.c I2C.c systick.c
  group Sources/CMSIS
    CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Sources/GD32F30x_standard_peripheral
    GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Sources/Startup
    CMSIS/GD/GD32F30x/Source/IAR/: startup_gd32f30x_hd.s
