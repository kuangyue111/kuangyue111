<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\IMCU_APP\IAR\IMCU.ewp</path>
  </project>
  <batchBuild/>
</workspace>


